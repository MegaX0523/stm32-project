# Keil uVision project test2.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test2
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\System;.\Driver;.\App
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ./App/: main.c app.h OLEDShow.h OLEDShow.c
  group System
    ./System/: Delay.c Delay.h Interrupt.c Interrupt.h Timer.c Timer.h DMA.c DMA.h
  group Driver
    ./Driver/: LED.c LED.h PassiveBuzzer.c PassiveBuzzer.h KEY.h LightSensor.c LightSensor.h OLED.c OLED.h OLED_Font.h Encoder.c Encoder.h ColorLED.c ColorLED.h Servo.c Servo.h Motor.c Motor.h InputCapture.c InputCapture.h AD.c AD.h Serial.c Serial.h MyI2C.c MyI2C.h MPU6050.c MPU6050.h SPI.c SPI.h W25Q64.c W25Q64.h W25Q64_INS.h
    ./driver/: KEY.c
software components: CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.6.0, Device:StdPeriph Drivers:DMA 3.6.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
